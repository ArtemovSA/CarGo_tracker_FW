<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Bootloader\bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CarGo_tracker.ewp</path>
  </project>
  <batchBuild/>
</workspace>


