# IAR project CarGo_tracker.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG330F128 SiliconLaboratories EFM32LG330F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32LG330F128; RTOS_DELAY
  ICCARM.CCIncludePath2: $PROJ_DIR$; RTOS; RTOS\include; RTOS\portable; ..\..\library\EFM32\CMSIS\Include; ..\..\library\EFM32\Device\SiliconLabs\EFM32LG\Include; ..\..\library\EFM32\Device\SiliconLabs\EFM32LG\Source\IAR; ..\..\library\EFM32\emlib\inc; ..\..\library\EFM32\emlib\src; ..\..\library\EFM32\Device\SiliconLabs\EFM32LG; Drivers\I2C; Libs\Delay; Drivers\MMA8452Q; Libs\Task_tranfer; Libs\Device_ctrl; Libs\CRC16; Libs\CRC8; Libs\ADD_func; Drivers\Flash; Tasks\I2C_gate_task; Drivers\ADC; Libs\Date_time; Libs\USB_ctrl; Drivers\USB_VCP\bsp; Drivers\USB_VCP\usb\inc; Drivers\USB_VCP\usb\src; Drivers\USB_VCP; Tasks\Modem_gate_task; Drivers\UART; Tasks\Main_task; Tasks\Monitor_task; Libs\GNSS; Libs\Wialon_IPS2; Libs\Service_ctrl; Tasks\Tracker_task; Libs\Clock; Tasks\Monitor_task; Libs\DS18B20; Drivers\OneWire; API\ModemAPI; Libs\Modem_lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: MicroGo_tracker.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\JOB\ARM\EFM32\IAR workspace\CarGo_tracker_FW\EFM32LG330F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group API/Modem
    API/ModemAPI/: ModemAPI.c ModemAPI.h
  group Device ctrl
    Libs/Device_ctrl/: Device_ctrl.c Device_ctrl.h
  group Drivers/ADC
    Drivers/ADC/: ADC.c ADC.h
  group Drivers/Ext flash
    Drivers/Flash/: EXT_Flash.c EXT_Flash.h
  group Drivers/I2C
    Drivers/I2C/: I2C.c I2C.h
  group Drivers/MMA8452Q
    Drivers/MMA8452Q/: MMA8452Q.c MMA8452Q.h
  group Drivers/OneWire
    Drivers/OneWire/: onewire.c onewire.h
  group Drivers/UART
    Drivers/UART/: UART.c UART.h
  group Drivers/USB_VCP
    Drivers/USB_VCP/bsp/: bsp.h
    Drivers/USB_VCP/: bspconfig.h cdc.c cdc.h descriptors.c descriptors.h dmactrl.c dmactrl.h usbconfig.h
  group Drivers/USB_VCP/USB_lib/inc
    Drivers/USB_VCP/usb/inc/: em_usb.h em_usbd.h em_usbh.h em_usbhal.h em_usbtypes.h
  group Drivers/USB_VCP/USB_lib/src
    Drivers/USB_VCP/usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbh.c em_usbhal.c em_usbhep.c em_usbhint.c em_usbtimer.c
  group Libs/ADD funcs
    Libs/ADD_func/: ADD_func.h
  group Libs/Clock
    Libs/Clock/: Clock.c Clock.h
  group Libs/CRC/CRC16
    Libs/CRC16/: CRC16.c CRC16.h
  group Libs/CRC/CRC8
    Libs/CRC8/: CRC8.c CRC8.h
  group Libs/Delay
    Libs/Delay/: Delay.c Delay.h
  group Libs/DS18B20
    Libs/DS18B20/: ds18b20.c ds18b20.h ds18b20Config.h
  group Libs/GNSS
    Libs/GNSS/: GNSS.c GNSS.h
  group Libs/Modem
    Libs/Modem_lib/: Modem.c Modem.h
  group Libs/Service_ctrl
    Libs/Service_ctrl/: Service_ctrl.c Service_ctrl.h
  group Libs/Task transfer
    Libs/Task_tranfer/: Task_transfer.c Task_transfer.h
  group Libs/USB_ctrl
    Libs/USB_ctrl/: USB_ctrl.c USB_ctrl.h
  group Libs/Wialon_IP2
    Libs/Wialon_IPS2/: wialon_ips2.c wialon_ips2.h
  group RTOS
    ./: FreeRTOSConfig.h
    RTOS/: heap_2.c
  group RTOS/inc
    RTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group RTOS/port
    RTOS/portable/: port.c portasm.s portmacro.h
  group RTOS/src
    RTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group System/CMSIS
    ../../library/EFM32/CMSIS/Include/: arm_math.h core_cm3.h
  group System/Device/inc
    ../../library/EFM32/Device/SiliconLabs/EFM32LG/Include/: efm32lg330f128.h efm32lg_acmp.h efm32lg_adc.h efm32lg_aes.h efm32lg_af_pins.h efm32lg_af_ports.h efm32lg_burtc.h efm32lg_burtc_ret.h efm32lg_calibrate.h efm32lg_cmu.h efm32lg_dac.h efm32lg_devinfo.h efm32lg_dma.h efm32lg_dma_ch.h efm32lg_dma_descriptor.h efm32lg_dmactrl.h efm32lg_dmareq.h efm32lg_ebi.h efm32lg_emu.h efm32lg_etm.h efm32lg_gpio.h efm32lg_gpio_p.h efm32lg_i2c.h efm32lg_lcd.h efm32lg_lesense.h efm32lg_lesense_buf.h efm32lg_lesense_ch.h efm32lg_lesense_st.h efm32lg_letimer.h efm32lg_leuart.h efm32lg_msc.h efm32lg_pcnt.h efm32lg_prs.h efm32lg_prs_ch.h efm32lg_prs_signals.h efm32lg_rmu.h efm32lg_romtable.h efm32lg_rtc.h efm32lg_timer.h efm32lg_timer_cc.h efm32lg_uart.h efm32lg_usart.h efm32lg_usb.h efm32lg_usb_diep.h efm32lg_usb_doep.h efm32lg_usb_hc.h efm32lg_vcmp.h efm32lg_wdog.h em_device.h system_efm32lg.h
  group System/Device/src
    ../../library/EFM32/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.c
    ../../library/EFM32/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group System/InitDevice
    ./: InitDevice.c InitDevice.h
  group System/Perefery_Libs/inc
    ../../library/EFM32/emlib/inc/: em_acmp.h em_adc.h em_aes.h em_assert.h em_bitband.h em_burtc.h em_bus.h em_chip.h em_cmu.h em_common.h em_cryotimer.h em_crypto.h em_dac.h em_dbg.h em_dma.h em_ebi.h em_emu.h em_gpcrc.h em_gpio.h em_i2c.h em_idac.h em_int.h em_lcd.h em_ldma.h em_lesense.h em_letimer.h em_leuart.h em_mpu.h em_msc.h em_opamp.h em_part.h em_pcnt.h em_prs.h em_ramfunc.h em_rmu.h em_rtc.h em_rtcc.h em_system.h em_timer.h em_usart.h em_vcmp.h em_version.h em_wdog.h
  group System/Perefery_Libs/src
    ../../library/EFM32/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_cryotimer.c em_crypto.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group TASKS/I2C_gate_task
    Tasks/I2C_gate_task/: I2C_gate_task.c I2C_gate_task.h
  group TASKS/Modem_gate_task
    Tasks/Modem_gate_task/: Modem_gate_task.c Modem_gate_task.h
  group TASKS/Monitor_task
    Tasks/Monitor_task/: Monitor_task.c Monitor_task.h
  group TASKS/Tracker_task
    Tasks/Tracker_task/: Tracker_task.c Tracker_task.h
